# Keil uVision project FreeRTOS_GD32F303CCT6.uvprojx, settings and files
target FreeRTOS_GD32F303 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F303 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVERm,__DEBUG
  c misc: --gnu --diag_suppress=1295 --locale=english
  c include: ..\code\Firmware\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\code\Firmware\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;..\code\Firmware\GD32F30x_Firmware_Library\CMSIS;..\code\Firmware\GD32F30x_Firmware_Library;..\code\middleware\FreeRTOSv9.0.0\FreeRTOS\Source\include;..\code\middleware\FreeRTOSv9.0.0\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\code\middleware\FreeRTOSv9.0.0\FreeRTOS;..\code\sys_app;..\code\sys_bsp;..\code\sys_dev
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group sys_app
    ../code/sys_app/: main.c base_typle.h
    ../code/Firmware/GD32F30x_Firmware_Library/: gd32f30x_it.c systick.c
    ../code/middleware/FreeRTOSv9.0.0/FreeRTOS/: FreeRTOSConfig.h
  group sys_bsp
    ../code/sys_bsp/: bsp.c
  group sys_debug
    ../code/sys_debug/: myprint.c
  group middleware\freertos
    ../code/middleware/FreeRTOSv9.0.0/FreeRTOS/Source/: list.c queue.c tasks.c event_groups.c croutine.c timers.c
    ../code/middleware/FreeRTOSv9.0.0/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../code/middleware/FreeRTOSv9.0.0/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Firmware\peripheral
    ../code/Firmware/GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Firmware\CMSIS
    ../code/Firmware/GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../code/Firmware/GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
