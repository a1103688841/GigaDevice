# IAR project GD32303E_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xE GD GD32F303xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_HD
  ICCARM.CCIncludePath2: ..; ..\..\..\..\GD32F30x_Firmware_Library\CMSIS; ..\..\..\Utilities; ..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include; ..\..\..\..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include; D:\E\SVN\fwlib\GD_Board_Firmware_Routine\GD3223\GD32F30x_Demo_Suites\GD32303E_EVAL_Demo_Suites\Projects\13_I2S_Audio_Player\Soft_Drive
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32303E_EVAL.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: gd32f30x_it.c main.c systick.c
  group CMSIS
    ../../../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Doc
    ../: readme.txt
  group GD32F30x_EVAL
    ../../../Utilities/: gd32f303e_eval.c
  group GD32F30x_Peripherals
    ../../../../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: pcm1770.c pcm1770.h spi_i2s.c spi_i2s.h test_wave_data.h
  group Startup
    ../../../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_hd.s
