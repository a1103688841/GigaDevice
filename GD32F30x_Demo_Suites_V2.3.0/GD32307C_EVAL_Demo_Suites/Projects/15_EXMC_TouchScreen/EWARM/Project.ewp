# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F307xC GD GD32F307xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_CL
  ICCARM.CCIncludePath2: ..; ..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include; ..\..\..\..\GD32F30x_Firmware_Library\CMSIS; ..\..\..\..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include; ..\..\..\..\GD32F30x_Firmware_Library\CMSIS\GD; ..\..\..\Utilities; ..\Soft_Drive; ..\..\..\Utilities\LCD_Commom
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F307xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: gd32f30x_it.c main.c systick.c
  group CMSIS
    ../../../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Doc
    ../: readme.txt
  group GD32F30x_EVAL
    ../../../Utilities/: gd32f307c_eval.c gd32f307c_lcd_eval.c
  group GD32F30x_Peripherals
    ../../../../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: picture.c touch_panel.c
  group Startup
    ../../../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_cl.s
