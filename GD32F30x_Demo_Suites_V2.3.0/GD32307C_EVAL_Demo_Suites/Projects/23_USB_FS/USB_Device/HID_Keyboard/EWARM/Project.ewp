# IAR project Project.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F307xC GD GD32F307xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F30X_CL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include; ..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include; ..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbfs_library\device\class\hid\Include; ..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbfs_library\device\core\Include; ..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbfs_library\driver\Include; ..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbfs_library\ustd\class\hid; ..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: app.c gd32f30x_hw.c gd32f30x_it.c hid_keyboard_itf.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group Doc
    ../: readme.txt
  group GD32F30x_EVAL
    ../../../../../Utilities/: gd32f307c_eval.c
  group GD32F30x_Peripherals
    ../../../../../../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_ctc.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c
  group Startup
    ../../../../../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_cl.s
  group USB_Class
    ../../../../../../GD32F30x_Firmware_Library/GD32F30x_usbfs_library/device/class/hid/Source/: standard_hid_core.c
  group USB_Device
    ../../../../../../GD32F30x_Firmware_Library/GD32F30x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../../GD32F30x_Firmware_Library/GD32F30x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
